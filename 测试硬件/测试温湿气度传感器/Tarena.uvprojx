# Keil uVision project Tarena.uvprojx, settings and files
target Target 1 (5060750::V5.06 update 6 (build 750)::ARMCC)
  device: STM32F103ZE STMicroelectronics
  pack: Keil.STM32F1xx_DFP.1.0.5
  cpu: IRAM(0x20000000,0x10000) IROM(0x08000000,0x80000) CPUTYPE("Cortex-M3") CLOCK(12000000) ELITTLE
  output: Tarena +hex
  c flags: Optim=1 OneElfS=1 uC99=1 uGnu=1 v6Lang=1 v6LangP=1 wLevel=2
  c define: USE_STDPERIPH_DRIVER,STM32F10X_HD
  c include: .\User;.\APP\LED;.\Libraries\CMSIS;.\Libraries\STM32F10X_StdPeriph_Driver\inc;.\APP\BEEP;.\APP\SYS;.\APP\SysTick;.\APP\KEY;.\APP\EXTI;.\APP\UART;.\APP\INIT;.\APP\CMD;.\APP\INTERRUPT;.\APP\AT24C02;.\APP\IIC;.\APP\DS18B20;.\APP\DMA;.\APP\TIM;.\APP\UART;.\APP\ESP8266;.\APP\HMAC\HMAC\inc;.\APP\MQTT;.\APP\RUN;.\APP\OLED;.\APP\PWM;.\APP\UART;.\APP\MODBUS
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x80000
  memory RVCT9: RAM 0x20000000 size 0x10000
  group User
    ./User/: main.c stm32f10x_it.c
  group Startup
    ./Libraries/CMSIS/: startup_stm32f10x_hd.s
  group StdPeriph_Driver
    ./Libraries/STM32F10X_StdPeriph_Driver/src/: stm32f10x_gpio.c stm32f10x_rcc.c misc.c stm32f10x_exti.c stm32f10x_usart.c stm32f10x_i2c.c stm32f10x_dma.c stm32f10x_tim.c
  group CMSIS
    ./Libraries/CMSIS/: core_cm3.c system_stm32f10x.c
  group APP
    ./APP/LED/: led.c
    ./APP/BEEP/: beep.c
    ./APP/SysTick/: systick.c
    ./APP/KEY/: key.c
    ./APP/EXTI/: exti.c
    ./APP/UART/: uart.c uart3.c uart2.c
    ./APP/INIT/: init.c
    ./APP/CMD/: cmd.c
    ./APP/INTERRUPT/: interrupt.c
    ./APP/AT24C02/: at24c02.c
    ./APP/IIC/: iic.c
    ./APP/DS18B20/: ds18b20.c
    ./APP/DMA/: dma.c
    ./APP/TIM/: timer4.c timer3.c
    ./APP/ESP8266/: esp8266.c
    ./APP/HMAC/HMAC/scr/: utils_hmac.c utils_md5.c utils_sha1.c
    ./APP/MQTT/: mqtt.c
    ./APP/RUN/: run.c
    ./APP/OLED/: oled.c
    ./APP/PWM/: pwm.c
    ./APP/MODBUS/: modbus.c
